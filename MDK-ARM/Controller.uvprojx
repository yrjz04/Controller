# Keil uVision project Controller.uvprojx, settings and files
target Controller (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Controller +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Middleware
    ../Src/Middleware/MTimer/: MTimer.c
    ../Src/Middleware/Protocol/: Protocol.c
    ../Src/Middleware/Pid/: Pid.c
  group Hardware
    ../Src/Hardware/Drv_Bluetooth/: Drv_Bluetooth.c
    ../Src/Hardware/Drv_Encoder/: Drv_Encoder.c
    ../Src/Hardware/Drv_Heater/: Drv_Heater.c
    ../Src/Hardware/Drv_Lcd/: Drv_Lcd.c uc1609.c
    ../Src/Hardware/Drv_Motor/: Drv_Motor.c
    ../Src/Hardware/Drv_Sensor/: Drv_Sensor.c max6675.c
    ../Src/Hardware/Drv_Uart/: Drv_Uart.c
    ../Src/Hardware/Drv_Spi/: Drv_Spi.c
  group System
    ../Src/System/: Application.c System_DataPool.c System_Callback.c System_Debug.c System_Config.h
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
